# Keil uVision project BLDC.uvprojx, settings and files
target MPro (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ult +hex
  AfterMake: fromelf.exe --bin --output ./ult.bin ./ult.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\stm32_lib;..\Device\Board;..\Device\DataProces;..\Device\Motor;..\Device\OLED;..\Device\Motor;..\Device\Servo;..\Device\IoT\WIFIDevice;..\Device\syn500r;..\Device\EFlash;..\Device\PS2;..\Device\AT;..\Device\PIDCount;..\Device\MEMS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../: main.c
    ../Device/Board/: BoardLib.c
    ../stm32_lib/: stm32f10x_Init.c delay.c Interrupt.c
    ./: startup_stm32f10x_hd.s
  group Mymath
    ../Device/DataProces/: KeyFI.c DataProces.c
  group Motor
    ../Device/Motor/: MotorDrive.c
  group Servo
    ../Device/Servo/: Servo.C
  group Syn500
    ../Device/syn500r/: syn500r.c
  group EPFlash
    ../Device/EFlash/: EEPFlash.c stm32_flash.c
  group PS2
    ../Device/PS2/: PS2.C
  group AT
    ../Device/AT/: AT_Driver.c AT_Runing.c LXU_AtRISC.c
  group PID
    ../Device/PIDCount/: PID.c
  group MEMS
    ../Device/MEMS/: MPU6050.c
  group I2C
    ../Device/OLED/: STM32_I2C.c
software components: CMSIS:CORE 5.4.0
